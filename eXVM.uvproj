# Keil uVision project eXVM.uvproj, settings and files
target eXVM (ARM-ADS)
  device: LPC810M021 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x100003FF) IROM(0-0x0FFF) CLOCK(12000000) CPUTYPE("Cortex-M0+")
  output: dsp +hex
  c flags: Optim=4 OneElfS=1
  c define: ARM_MATH_CM0, USE_LPC800
  c misc: --c99 --loose_implicit_cast --gnu
  c include: ..\..\..\..\INC\NXP\LPC8xx;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x10000000 size 0x400
  group User
    ./src/: lpc8xx_gpio.c lpc8xx_mrt.c lpc8xx_nmi.c lpc8xx_uart.c main.c eXVM.c device_depend.c
  group Lib-CM0
    C:/Keil/ARM/CMSIS/Lib/ARM/: arm_cortexM0l_math.lib
  group Core-CM0+
    C:/Keil/ARM/CMSIS/Include/: core_cm0plus.h arm_math.h
  group Device-LPC800
    ./: system_LPC8xx.c startup_LPC8xx.s
  group include
    ./include/: eXVM.h lpc8xx_gpio.h lpc8xx_i2c.h lpc8xx_mrt.h lpc8xx_nmi.h lpc8xx_pmu.h lpc8xx_spi.h lpc8xx_uart.h lpc8xx_wdt.h lpc8xx_wkt.h type.h device_depend.h
